# IAR project RLS_M32T.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZN32xxx2 NXP KEAZN32xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: Project_Headers; lin_cfg; Project_Settings\Startup_Code; Sources; ..\LIN_stack_S12_4_6_6\LIN_Stack\include; ..\LIN_stack_S12_4_6_6\LIN_Stack\coreapi; ..\LIN_stack_S12_4_6_6\LIN_Stack\lowlevel; ..\LIN_stack_S12_4_6_6\LIN_Stack\transport; ..\LIN_stack_S12_4_6_6\LIN_Stack\diagnostic; ..\LIN_stack_S12_4_6_6\LIN_Stack\bsp\AUTOBAUD; ..\LIN_stack_S12_4_6_6\LIN_Stack\bsp\UART; MLX75308
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RLS_M32T.bin
  ILINK.IlinkOutputFile: RLS_M32T.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lin_cfg
    lin_cfg/: lin_cfg.c lin_cfg.h lin_hw_cfg.h
  group LIN_Stack/bsp/AUTOBAUD
    ../LIN_stack_S12_4_6_6/LIN_Stack/bsp/AUTOBAUD/: lin_lld_autobaud.c lin_lld_autobaud.h
  group LIN_Stack/bsp/UART
    ../LIN_stack_S12_4_6_6/LIN_Stack/bsp/UART/: lin_isr.c lin_lld_timesrv.c lin_lld_timesrv.h lin_lld_uart.c lin_lld_uart.h
  group LIN_Stack/coreapi
    ../LIN_stack_S12_4_6_6/LIN_Stack/coreapi/: lin_common_api.c lin_common_proto.c lin_lin21_api.c lin_lin21_proto.c
  group LIN_Stack/diagnostic
    ../LIN_stack_S12_4_6_6/LIN_Stack/diagnostic/: lin_diagnostic_service.c
  group LIN_Stack/lowlevel
    ../LIN_stack_S12_4_6_6/LIN_Stack/lowlevel/: lin.c lin.h
  group LIN_Stack/transport
    ../LIN_stack_S12_4_6_6/LIN_Stack/transport/: lin_commontl_api.c lin_commontl_proto.c
  group MLX75308
    MLX75308/: mlx75308.c mlx75308.h
  group Sources
    Sources/: a_light.c a_light.h a_wipe.c a_wipe.h calibrations.c cbuff.c cbuff.h flash.c flash.h lin_data.c lin_data.h low_power.c low_power.h main.c rtc.c rtc.h sma.c sma.h spi.c spi.h table_lookup.c table_lookup.h
  group Startup_Code
    Project_Settings/Startup_Code/: __arm_end.c __arm_start.c kinetis_sysinit.c kinetis_sysinit.h runtime_configuration.h
